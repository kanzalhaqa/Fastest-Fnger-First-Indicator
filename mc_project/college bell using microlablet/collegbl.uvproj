# Keil uVision project collegbl.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: bell000 +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: collegbl.c
